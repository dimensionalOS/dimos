Commit message: refactor(sim2): package desk assets and keep synthetic worlds in tests

File: assets/g1_desk/desk.urdf (robot description, URDF)
Before this commit: robot office_desk, 1 links, 0 joints
Links:
- link desk: geometry collision box size=.05 .72 .63; collision box size=.05 .72 .63
