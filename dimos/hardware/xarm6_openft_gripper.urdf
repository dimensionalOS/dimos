Commit message: updated urdf

File: dimos/hardware/xarm6_openft_gripper.urdf (robot description, URDF)
Before this commit: robot xarm_openft_gripper, 25 links, 24 joints
Joints:
- joint zed_fixed_joint: origin xyz=0 .08605 .02325 rpy=0 -1.5707 -1.5707 -> xyz=0 -.08605 .02325 rpy=0 -1.5707 1.5707
